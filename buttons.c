//------------------------------------------------------------------------------
//             __             __   ___  __
//     | |\ | /  ` |    |  | |  \ |__  /__`
//     | | \| \__, |___ \__/ |__/ |___ .__/
//
//------------------------------------------------------------------------------

#include "buttons.h"
#include "sam.h"

//------------------------------------------------------------------------------
//      __   ___  ___         ___  __
//     |  \ |__  |__  | |\ | |__  /__`
//     |__/ |___ |    | | \| |___ .__/
//
//------------------------------------------------------------------------------

#define BTN_0 (PORT_PB09)
#define BTN_0_GROUP (1)
#define BTN_0_PIN (PIN_PB09%32)

#define BTN_1 (PORT_PA04)
#define BTN_1_GROUP (0)
#define BTN_1_PIN (PIN_PA04%32)

#define BTN_ACTIVE (PORT_PA08)
#define BTN_ACTIVE_GROUP (0)
#define BTN_ACTIVE_PIN (PIN_PA08%32)


//------------------------------------------------------------------------------
//     ___      __   ___  __   ___  ___  __
//      |  \ / |__) |__  |  \ |__  |__  /__`
//      |   |  |    |___ |__/ |___ |    .__/
//
//------------------------------------------------------------------------------

//------------------------------------------------------------------------------
//                __          __        ___  __
//     \  /  /\  |__) |  /\  |__) |    |__  /__`
//      \/  /~~\ |  \ | /~~\ |__) |___ |___ .__/
//
//------------------------------------------------------------------------------

//------------------------------------------------------------------------------
//      __   __   __  ___  __  ___      __   ___  __
//     |__) |__) /  \  |  /  \  |  \ / |__) |__  /__`
//     |    |  \ \__/  |  \__/  |   |  |    |___ .__/
//
//------------------------------------------------------------------------------

//------------------------------------------------------------------------------
//      __        __          __
//     |__) |  | |__) |    | /  `
//     |    \__/ |__) |___ | \__,
//
//------------------------------------------------------------------------------

//=============================================================================
void buttons_init(void)
{
  // Turn on the input enables for button bits and button active bit
  PORT->Group[BTN_0_GROUP].PINCFG[BTN_0_PIN].bit.INEN = 1;
  PORT->Group[BTN_1_GROUP].PINCFG[BTN_1_PIN].bit.INEN = 1;
  PORT->Group[BTN_ACTIVE_GROUP].PINCFG[BTN_ACTIVE_PIN].bit.INEN = 1;
  
  // Make sure the directions regs are configured as inputs
  PORT->Group[BTN_0_GROUP].DIRCLR.reg = BTN_0;
  PORT->Group[BTN_1_GROUP].DIRCLR.reg = BTN_1;
  PORT->Group[BTN_ACTIVE_GROUP].DIRCLR.reg = BTN_ACTIVE;
}

//==============================================================================
// Buttons are active high after encoder
// Button 0 - {BTN_1, BTN_0} = 00
// Button 1 - {BTN_1, BTN_0} = 01
// Button 2 - {BTN_1, BTN_0} = 10
// Button 3 - {BTN_1, BTN_0} = 11
//==============================================================================
bool buttons_get(uint8_t button)
{
  bool retval = false;
  uint8_t button_value = 0;
  
  // Set button_value to encoded button value
  if ((PORT->Group[BTN_0_GROUP].IN.reg) & (BTN_0))
  {
	  button_value = 1;
  }
  if ((PORT->Group[BTN_1_GROUP].IN.reg) & (BTN_1))
  {
	  button_value = button_value + 2;
  }
  
  if ((PORT->Group[BTN_ACTIVE_GROUP].IN.reg) & (BTN_ACTIVE)) // if button is active
      {
	  if (button == 0) // Button 0
	    {
	      if (button_value == 0) 
	      {
	        retval = true;
	      }
	    }
	    else if (button == 1) // Button 1
	    {
	      if (button_value == 1)  
	  	  { 
	        retval = true;
	      }
	    }
	    else if (button == 2) // Button 2
	    {
	  	  if (button_value == 2)
	  	  {
	  		  retval = true;
	  	  }
	    }
	    else // Button 3
	  	  if (button_value == 3)
	  	  {
	  		  retval = true;
	  	  }
	  	  
	   }
  return retval;
}

//------------------------------------------------------------------------------
//      __   __              ___  ___
//     |__) |__) | \  /  /\   |  |__
//     |    |  \ |  \/  /~~\  |  |___
//
//------------------------------------------------------------------------------

//------------------------------------------------------------------------------
//      __                  __        __        __
//     /  `  /\  |    |    |__)  /\  /  ` |__/ /__`
//     \__, /~~\ |___ |___ |__) /~~\ \__, |  \ .__/
//
//------------------------------------------------------------------------------

//------------------------------------------------------------------------------
//        __   __  , __
//     | /__` |__)  /__`   
//     | .__/ |  \  .__/
//
//------------------------------------------------------------------------------
